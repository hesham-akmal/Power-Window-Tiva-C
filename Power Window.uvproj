# Keil uVision project Power Window.uvproj, settings and files
target freertos_demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Power Window
  AfterMake: fromelf --bin --output .\rvmdk\Power Window.bin .\rvmdk\Power Window.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: FreeRTOS\Source\portable\RVDS\ARM_CM4F;FreeRTOS;FreeRTOS\Source\include;.\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: freertos_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ./: queue.c startup_rvmdk.S freertos_demo.c android_listen.c LCD.h LCD.c PORTS.h states_tasks.c engine_task.c
    FreeRTOS/Source/portable/MemMang/: heap_2.c
    FreeRTOS/Source/: list.c tasks.c
    FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    drivers/: rgb.c buttons.c
    utils/: uartstdio.c ustdlib.c
  group Libraries
    driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
